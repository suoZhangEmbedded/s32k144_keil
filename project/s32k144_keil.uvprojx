# Keil uVision project s32k144_keil.uvprojx, settings and files
target S32K144 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: s32k144_keil
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user\app;..\user\FreeRTOS\Source\include;..\user\FreeRTOS\Source\portable\MemMang;..\user\SEGGER_RTT\RTT;..\user\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash.sct
  group App
    ../user/app/: main.c freertos_tickless.c bsp_rtc.c bsp_vlps.c bsp_lptmr.c bsp_lpuart.c kfifo.c bsp_spi.c
  group FreeRTOS
    ../user/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../user/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../user/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SEGGER_RTT
    ../user/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.0.0
